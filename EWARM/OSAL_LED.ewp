# IAR project OSAL_LED.ewp, settings and files
configuration OSAL_LED (ARM, debug)
  General.OGChipSelectEditMenu: STM32L071CB ST STM32L071CB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L071xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\OSAL\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: OSAL_LED.hex
  ILINK.IlinkOutputFile: OSAL_LED.out
  ILINK.IlinkIcfFile: stm32l071xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l071xx.s
  group Application/User/Core
    ../Core/Src/: gpio.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
  group Osal/App
    ../OSAL/application/: osal_main.c serial_task.c
  group Osal/Inc
    ../OSAL/include/: application.h osal.h osal_event.h osal_memory.h osal_msg.h osal_timer.h timer.h type.h
  group Osal/Src
    ../OSAL/osal/: osal.c osal_event.c osal_memory.c osal_msg.c osal_timer.c
    ../OSAL/hal/: timer.c
